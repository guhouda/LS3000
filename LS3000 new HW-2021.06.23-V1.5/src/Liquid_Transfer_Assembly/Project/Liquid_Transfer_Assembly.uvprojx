# Keil uVision project Liquid_Transfer_Assembly.uvprojx, settings and files
target Liquid_Transfer_Assembly (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Liquid_Transfer_Assembly +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_USB_OTG_FS,
  c misc: --C99
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\APP\inc;..\User\BSP\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ../User/: startup_stm32f429_439xx.s
  group USER
    ../User/: main.c stm32f4xx_it.c
  group APP
    ../User/APP/src/: MotorConfig.c UartCallBack.c HandleData.c BackWork.c APP_Debug.c
    ../User/: app_config.h
  group BSP
    ../User/: bsp.c
    ../User/BSP/src/: uartDriver.c bsp_Can_Drive.c bsp_timer.c bsp_Motor_Drive.c bsp_WalveDrive.c bsp_sensor.c bsp_Scan.c bsp_work.c DriverMotorTime.c MotorMove.c bsp_spiflash.c bsp_liquid.c bsp_led.c bsp_Adc_Drive.c C_T_value.c
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_fmc.c stm32f4xx_can.c stm32f4xx_adc.c stm32f4xx_dac.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
